# Keil uVision project Task 19(1).uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Task 19(1) +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../../../Downloads/8051-Microcontroller-Training-Tasks-main/Task_19 Keypad Interfacing and Multi-Application State Machine/Task 19_1 Keypad Interfacing/: keypad.h keypad_1.h lcd.h keypad.c keypad_1.c lcd.c main.c
