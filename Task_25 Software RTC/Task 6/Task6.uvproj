# Keil uVision project Task6.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODP2
  output: Task6 +hex
  c flags: Optimize=8
  group Source Group 1
    ./: STARTUP.A51 main.c lcd.c lcd.h ds1302.c ds1302.h
