# Keil uVision project TAsk 26.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000) MODP2
  output: Task26 +hex
  c flags: Optimize=8
  group Source Group 1
    ./: STARTUP.A51 main.c LCD.c LCD.h Freq gene.c Freq coun.c Freq gene.h Freq coun.h
