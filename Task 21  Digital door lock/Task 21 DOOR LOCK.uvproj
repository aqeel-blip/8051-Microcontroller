# Keil uVision project Task 21 DOOR LOCK.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Task 21 DOOR LOCK +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Door lock.c
